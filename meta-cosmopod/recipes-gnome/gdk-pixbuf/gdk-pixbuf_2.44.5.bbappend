# Keep Wrynose packaging and use the upstream 2.44 maintenance release.
PV = "2.44.8"
SRC_URI[archive.sha256sum] = "919f529512961a12e81cd4b4b466a48c3933469e7f9a310c6513cd4fb252ba3c"
