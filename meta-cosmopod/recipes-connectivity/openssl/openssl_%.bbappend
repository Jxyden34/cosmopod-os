# Backport OE-Core db81c1a42a0f552d9a8ec124f004ae2063d58c33.
# Stay on the 3.5 LTS series and preserve the baseline patches/configuration.
PV = "3.5.8"
SRC_URI[sha256sum] = "a8f84a39918ec6415ce765d9b429d313ba97b8143169c172e734b9514464f5b2"
