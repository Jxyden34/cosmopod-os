# Keep Wrynose's recipe location and packaging while using the security release.
PV = "3.14.10"
SRC_URI[sha256sum] = "de414a57119abef52784d8993e341d53aed635fc2b05c2607d9f98a2c5b72032"
