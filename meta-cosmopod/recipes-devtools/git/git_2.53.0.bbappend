# Keep Wrynose packaging and select the upstream 2.53 maintenance release.
PV = "2.53.1"
SRC_URI[tarball.sha256sum] = "80ced350b44beb50218d6f3546928a39c9b8d832fa484e3fcb9afcad702ae691"
