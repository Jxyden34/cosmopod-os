FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://CVE-2026-40164.patch"
