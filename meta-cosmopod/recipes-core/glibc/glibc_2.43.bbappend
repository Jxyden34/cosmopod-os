# The SRCREV_glibc pin in cosmopod.conf includes stable fixes 45e49b1,
# e6ae66c and 124e9ad on release/2.43/master. Keep this list tied to that pin.
CVE_STATUS_STABLE_BACKPORTS:append = " CVE-2026-84243 CVE-2026-100290 CVE-2026-115819"
