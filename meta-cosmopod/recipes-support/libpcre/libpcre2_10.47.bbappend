# Retain OE's packaging and ptest integration while using the security release.
# https://github.com/PCRE2Project/pcre2/releases/tag/pcre2-10.49
# The source and both licence checksums were verified against that release.
PV = "10.49"
SRC_URI[sha256sum] = "53c156e1ba416a20da8e65395daa132da0d80e76910424caca3fcdae7831d384"
